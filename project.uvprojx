# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 模板 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\Hardware;.\System;.\VL53L0X;.\VL53L0X\core\inc;.\VL53L0X\core\src;.\VL53L0X\demo;.\VL53L0X\platform\inc;.\VL53L0X\platform\src;.\Hardware\MPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Hardware
    ./Hardware/: Led.c Led.h PWM.c PWM.h AD.c AD.h oled.c oled.h OLED_Font.h key.c key.h UI.c UI.h
  group System
    ./System/: Delay.h Delay.c Timer.c Timer.h sys.c sys.h usart.c usart.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h PID_Control.c PID_Control.h
  group VL53L0X
    ./VL53L0X/core/inc/: vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h
    ./VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ./VL53L0X/demo/: vl53l0x_it.h vl53l0x_it.c vl53l0x_gen.h vl53l0x_gen.c vl53l0x_cali.h vl53l0x_cali.c vl53l0x.h vl53l0x.c
    ./VL53L0X/platform/inc/: vl53l0x_i2c.h vl53l0x_platform.h
    ./VL53L0X/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
